# Keil uVision project PrjSdkOsIpRom.uvproj, settings and files
target PrjSdkOsIpRom (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SdkFw +hex
  AfterMake: bin.bat
  c flags: Optim=4
  c define: USE_CORTEX_M3
  c misc: --littleend --loose_implicit_cast --feedback cmpl.fed --diag_suppress=3052
  c include: ..\..\Source\Include;..\..\Source\Ports\Cortex-M3;..\..\Source\uCOS-II;..\..\Source\BSP;..\..\Source\WiFi\include;..\..\Source\LwIP\src\include;..\..\Source\LwIP\port\include;..\..\Source\LwIP\src\include\ipv4;..\..\Source\LwIP\src\include\ipv6;..\..\Source\LwIP\src\include\lwip;..\..\Source\LwIP\src\include\netif;..\..\Source\LwIP\port\include\netif
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: scatter.scat
  link misc: --keep os_*.o --keep netdb.o(.text) --keep netdb.o(.data) --feedback link.fed
  group BSP
    ../../Source/BSP/: bsp.c cortexM3_it.c nvic.c printf.c timer.c uart.c spi.c flash.c mpu.c qspi.c cortexm3_macro.s gpio.c i2c.c i2s.c dma.c wdg.c sdio.c
  group BOOT
    ../../Source/BOOT/: CortexM3_startup.s
  group uCOS
    ../../Source/uCOS-II/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_tmr.c os_task.c os_time.c
  group Ports
    ../../Source/Ports/Cortex-M3/: cpu_a.asm os_cpu_c.c os_cpu_a.asm os_dmem.c
  group LWIP
    ../../Source/LwIP/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../Source/LwIP/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../Source/LwIP/src/core/: udp.c def.c dhcp.c dns.c lwip_init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c
    ../../Source/LwIP/src/netif/: etharp.c
    ../../Source/LwIP/port/: sys_arch.c lwIP.c
  group Sys
    ../../Source/Sys/: app_main.c main.c param.c rom_hook_tbl.c sys_mgmt.c util.c
  group Include
    ../../Source/Include/: app_cfg.h global.h includes.h param.h rom_hook_tbl.h task_util.h types_def.h util.h
  group DhcpServer
    ../../Source/App/DhcpServer/: dhcp_server.c
  group DnsServer
    ../../Source/App/DnsServer/: dns_server.c
  group Lib
    ../../Source/Lib/: wcore.lib
  group Gizwits
    ../../Source/App/GizWitsWifi/: gizwits_main.c
    ../../Source/App/GizWitsWifi/wifi/: directconfig.c Wifi_mode.c
    ../../Source/App/GizWitsWifi/system/: core_gagent.c gagent_login_cloud.c nl6621_drv.c xpgmain.c
    ../../Source/App/GizWitsWifi/lib/: adapter_ucos.c base64.c str_lib.c utilcoding.c ntp_client.c
    ../../Source/App/GizWitsWifi/lan/: lan.c mcu_common.c mcu_v4.c Socket.c
    ../../Source/App/GizWitsWifi/cloud/: http.c mqttlib.c MqttSTM.c mqttxpg.c
  group Dev
    ../../Source/App/GizWitsWifi/dev/: control.c light.c strip.c
